Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2022-05-24T09:30:53
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue May 24 09:30:53 2022 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\eb70296d-c86d-411c-b5e7-1dab5d63b9eb\8ff12912-1f87-4ae0-ac67-32e5ad021408\ifc * Database version: 5507 * Database creation date: Tue May 24 09:30:52 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue May 24 09:30:52 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue May 24 09:30:52 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 11918210_EU_APWM041_SST:59510041_EU_11918210_APWM041_SST, (2)
In: Default
Type - Material: z_Miele_Design_Alusilver
Type - Pset_BuildingElementProxyCommon - Reference: 59510041_EU_11918210_APWM041_SST
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 59510041_EU_11918210_APWM041_SST
Pset_BuildingElementProxyCommon - sets with these values: 2
